Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:07:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:07:33 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{B866A319-FC62-4CC5-97AC-AD0D2E384C0B}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:07:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:07:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:07:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: iq-unit_duco, BERSnl_67_EE_FB_iq-unit_duco:iq-unit_duco:200106
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: BERSnl_x_rgb 000 149 150 T00 groen_gen, BERSnl_n_plastic_zwart, BERSnl_o_glas_helder, BERSnl_n_plastic_grijs
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 164 mm; BERSnl_C_dikte: 58.5 mm; BERSnl_C_hoogte: 106 mm
Type - Electrical(Type) - BERSnl_E_c02_aantal_polen: 1; BERSnl_E_c02_actief_vermogen: 1.7 W; BERSnl_E_c02_arbeidsfactor: 1; BERSnl_E_c02_belastingsklasse: HVAC; BERSnl_E_c02_spanning: 220 V; BERSnl_E_c02_subklasse_motor: no
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSnl_C_code_ETIM: Intelligent bedieningselement; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC000205&classVersion=5; BERSnl_C_code_gtin: 5 4 2503715 030 9; BERSnl_C_code_product: 0000-4193; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: IQ-Unit_duco; BERSnl_C_model: IQ-Unit; BERSnl_C_revit_versie: 2016; BERSnl_C_type_comments: iq-unit; Description: IQ-Unit_duco; Manufacturer: Duco; Model: IQ-Unit; Type Comments: iq-unit; Type Name: iq-unit_duco; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - WT_V Display_materiaal: BERSnl_o_glas_helder; WT_V Knoppen_materiaal: BERSnl_n_plastic_grijs
Type - Model Properties(Type) - WT_I Aansluitingen: 24VDC voeding; Duco Wired; ModBus; schakelcontact (2x); PWM IN; PWM OUT; WT_I Bevestiging: DIN rail; WT_I Communicatie: RF en Wired; WT_I Kleur omkasting: Grijs/wit met kleurenlogo Duco; WT_I Protocol: Z-wave; WT_I Type: IQ-unit
Type - Other(Type) - Category: Electrical Equipment; BERSnl_E_c01_omschrijving: c1_communication connector; BERSnl_E_c02_omschrijving: c2_elektrische connector; Family Name: BERSnl_67_EE_FB_iq-unit_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.033179 m2; Volume: 0.00101696 m3
Electrical - Circuiting - Electrical Data: c2_elektrische connector 220 V/1-2 VA
Identity Data - Mark: 1
Other - Category: Electrical Equipment; Family: BERSnl_67_EE_FB_iq-unit_duco: iq-unit_duco; Family and Type: BERSnl_67_EE_FB_iq-unit_duco: iq-unit_duco; Schedule Level: Level: Level 1; Type: BERSnl_67_EE_FB_iq-unit_duco: iq-unit_duco; Type Id: BERSnl_67_EE_FB_iq-unit_duco: iq-unit_duco
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
