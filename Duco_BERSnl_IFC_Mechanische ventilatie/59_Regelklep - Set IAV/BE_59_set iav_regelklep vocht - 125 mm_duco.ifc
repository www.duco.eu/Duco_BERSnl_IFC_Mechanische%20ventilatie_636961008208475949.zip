Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:06:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:06:14 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{B6EB0571-DE75-45E0-A2E1-16E5273095E9}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:06:12 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:06:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:06:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138, BERSnl_59_DUA_UN_regelklep - set iav_duco:regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138:201255
In: Level 1
Type - PredefinedType: CONTROLDAMPER; Classification: 57.10.90.80 (Uniformat); Material: BERSnl_x_rgb 255 255 255 T00 wit_gen, BERSnl_x_rgb 000 149 150 T00 groen_gen
Type - Constraints(Type) - ZZZ_Behuizing_FamilyType_Duct Accessories: standard
Type - Dimensions(Type) - BERSnl_C_breedte: 192 mm; BERSnl_C_diepte: 138 mm; BERSnl_C_hoogte: 150 mm
Type - Electrical(Type) - BERSnl_E_c01_actief_vermogen: 7 W; BERSnl_E_c01_arbeidsfactor: 1; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 24 W; BERSnl_E_c01_spanning: 24 V; BERSnl_E_c01_stroom: 1 A; BERSnl_E_c01_subklasse_motor: yes; NLRS_E_c01_aantal_fasegeleiders: 1; WT_I Stand-By vermogen: 0.4 W
Type - Identity Data(Type) - Assembly Code: 57.10.90.80; BERSnl_C_code_artikel: -; BERSnl_C_code_ETIM: Regelklep rond luchtkanaal; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC011268&classVersion=3; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: duco_set intelli air valve - regelklep vocht; BERSnl_C_IFC_versie: 2x3; BERSnl_C_model: Set Intelli Air Valve; BERSnl_C_revit_versie: 2016; BERSnl_C_type: Regelklep Vocht; BERSnl_C_type_comments: Regelklep; Description: duco_set intelli air valve - regelklep vocht; Manufacturer: Duco; Model: Set Intelli Air Valve; OmniClass Number: 23.75.70.14.34; OmniClass Title: Air Duct Accessories; Type Comments: Regelklep; Type Name: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138; URL: http://www.duco.eu; WT_I BaseKeynote: 31.20
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 000 149 150 T00 groen_gen; BERSnl_C_materiaal_01: BERSnl_x_rgb 000 149 150 T00 groen_gen; BERSnl_C_materiaal_02: BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Mechanical(Type) - BERSnl_M_c01_diameter: 125 mm
Type - Model Properties(Type) - BERSnl_S_gewicht_bruto: 0.488; WT_I Communicatie: Wired met bovenliggende master (indien van toepassing), RF met onderliggende slave componenten; WT_I Toepasbaar in de volgende systemen: Duco CO2 System Collectief, Duco Comfort Plus System Collectief, Duco Tronic System Collectief, Duco Tronic Plus System Collectief
Type - Other(Type) - Category: Duct Accessories; BERSnl_E_c03_omschrijving: c03_connector; BERSnl_M_c01_omschrijving: c01_aansluiting; BERSnl_M_c02_omschrijving: c02_aansluiting; Family Name: BERSnl_59_DUA_UN_regelklep - set iav_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0928363 m2; Size: 125 mmø-125 mmø; Volume: 0.00382871 m3
Identity Data - Mark: 2
Insulation - Insulation Thickness: 0 mm; Overall Size: 125 mmø-125 mmø
Lining - Free Size: 125 mmø-125 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined,Power
Other - Category: Duct Accessories; Family: BERSnl_59_DUA_UN_regelklep - set iav_duco: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138; Family and Type: BERSnl_59_DUA_UN_regelklep - set iav_duco: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138; Type: BERSnl_59_DUA_UN_regelklep - set iav_duco: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138; Type Id: BERSnl_59_DUA_UN_regelklep - set iav_duco: regelklep vocht - 125 mm_duco_set iav_bxhxd 192x150x138
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
