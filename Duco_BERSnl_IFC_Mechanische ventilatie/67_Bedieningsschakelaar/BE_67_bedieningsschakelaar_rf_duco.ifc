Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:07:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:07:02 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{49F74719-D7AF-4011-8A3F-491B20412570}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:07:00 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:07:00 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:07:00 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcBuildingElementProxy: connector electrical_gen, BERSnl_XX_GM_FB_connector electrical_gen:connector electrical_gen:202906
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - BERSnl_C_description: connector electrical_gen; Type Name: connector electrical_gen
Type - Other(Type) - Category: Communication Devices; Family Name: BERSnl_XX_GM_FB_connector electrical_gen
Pset_BuildingElementProxyCommon - Reference: connector electrical_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Electrical - BERSnl_E_c02_aantal_polen: 1; BERSnl_E_c02_arbeidsfactor: 1; BERSnl_E_c02_belastingsklasse: HVAC; BERSnl_E_c02_subklasse_motor: no; BERSnl_E_c02_spanning: 230 V; BERSnl_E_vermogen: 1 W
Electrical - Circuiting - Electrical Data: c2_elektrische connector 230 V/1-1 VA
Identity Data - Mark: 4
Other - Category: Communication Devices; Family: BERSnl_XX_GM_FB_connector electrical_gen: connector electrical_gen; Family and Type: BERSnl_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type: BERSnl_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type Id: BERSnl_XX_GM_FB_connector electrical_gen: connector electrical_gen; WT_c1 Omschrijving: c2_elektrische connector; WT_c2 utility: no
Phasing - Phase Created: New Construction

# IfcDistributionControlElement: rf_duco_bedieningsschakelaar, BERSnl_67_COM_FB_bedieningsschakelaar_duco:rf_duco_bedieningsschakelaar:202905
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: BERSnl_n_plastic_wit, BERSnl_n_plastic_zwart
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Construction(Type) - WT_V Dikte afdekkader: 20 mm; WT_V Inbouwdiepte: 40 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 83 mm; BERSnl_C_dikte: 60 mm; BERSnl_C_hoogte: 83 mm
Type - Electrical(Type) - BERSnl_E_c02_aantal_polen: 1; BERSnl_E_c02_actief_vermogen: 1 W; BERSnl_E_c02_arbeidsfactor: 1; BERSnl_E_c02_belastingsklasse: HVAC; BERSnl_E_c02_spanning: 230 V; BERSnl_E_c02_subklasse_motor: no; WT_I Stand-By vermogen: 0.5 W
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSnl_C_code_ETIM: Bedieningselement /centraalplaat schakelmateriaal; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC000011&classVersion=6; BERSnl_C_code_gtin: 5 4 2503715 008 8; BERSnl_C_code_product: 0000-4176; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: rf_duco_bedieningschakelaar; BERSnl_C_model: bedieningsschakelaar; BERSnl_C_revit_versie: 2016; BERSnl_C_type: rf; BERSnl_C_type_comments: bedieningsschakelaar; Description: rf_duco_bedieningschakelaar; Manufacturer: Duco; Model: bedieningsschakelaar; Type Comments: bedieningsschakelaar; Type Name: rf_duco_bedieningsschakelaar; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-bedieningsschakelaar; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_n_plastic_wit
Type - Model Properties(Type) - WT_I Inbouwdoos_diepte: 40 mm; WT_I Kleurenindicatie LED_BLAUW: Visualisatie van de bedieningsschakelaar wanneer er wijzigingen doorgevoerd worden via de DucoBox; WT_I Kleurenindicatie LED_GEEL_knipperen: Overgangsfase (indien DucoBox niet in bereik); WT_I Kleurenindicatie LED_GROEN_snel knipperen: In netwerk en wachtend op onderliggende componenten (bvb. elektronische roosters); WT_I Kleurenindicatie LED_GROEN_traag knipperen: In netwerk; WT_I Kleurenindicatie LED_ROOD_snel knipperen: Bezig met aanmelden; WT_I Kleurenindicatie LED_ROOD_traag knipperen: Niet in netwerk; WT_I Kleur omkasting: zwarte bediening; WT_I Protocol: Z-wave; WT_I Type: RF_230VAC
Type - Other(Type) - Category: Communication Devices; BERSnl_E_c01_omschrijving: c1_communication connector; BERSnl_E_c02_omschrijving: c2_elektrische connector; Family Name: BERSnl_67_COM_FB_bedieningsschakelaar_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0170067 m2; Volume: 0.000419885 m3
Graphics - WT_V Positie annotatie x: 0; WT_V Positie annotatie y: 0; WT_V Verschuiving annotatie x: 0 mm; WT_V Verschuiving annotatie y: 0 mm
Identity Data - Mark: 3
Other - Category: Communication Devices; Family: BERSnl_67_COM_FB_bedieningsschakelaar_duco: rf_duco_bedieningsschakelaar; Family and Type: BERSnl_67_COM_FB_bedieningsschakelaar_duco: rf_duco_bedieningsschakelaar; Schedule Level: Level: Level 1; Type: BERSnl_67_COM_FB_bedieningsschakelaar_duco: rf_duco_bedieningsschakelaar; Type Id: BERSnl_67_COM_FB_bedieningsschakelaar_duco: rf_duco_bedieningsschakelaar
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
