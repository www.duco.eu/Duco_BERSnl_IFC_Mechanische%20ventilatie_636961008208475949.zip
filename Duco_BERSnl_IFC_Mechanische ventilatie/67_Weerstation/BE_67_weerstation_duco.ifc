Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:07:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:07:39 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{19A98F99-38E6-41AE-86FD-8B4E9BB571F4}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:07:37 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:07:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:07:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: weerstation_duco_bxhxd 94x126x96 mm, BERSnl_67_EF_FB_weerstation_duco:weerstation_duco_bxhxd 94x126x96 mm:199796
In: Level 1
Type - Classification: 67,1 (Uniformat); Material: BERSnl_x_rgb 255 255 255 T00 wit_gen, BERSnl_x_rgb 255 142 46 T00 goud_gen, BERSnl_x_rgb 244 244 244 T00_gen
Type - Constraints(Type) - Default Elevation: 1100 mm
Type - Construction(Type) - WT_V Dikte afdekkader: 13 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 94 mm; BERSnl_C_diepte: 96 mm; BERSnl_C_hoogte: 126 mm
Type - Electrical(Type) - BERSnl_E_c01_arbeidsfactor: 1; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 24 W; BERSnl_E_c01_spanning: 24 V; BERSnl_E_c01_stroom: 1 A; BERSnl_E_c01_subklasse_motor: no; BERSnl_E_c01_vermogen: 0.24 W; BERSnl_E_vermogen: 0.24 W; NLRS_E_c01_aantal_fasegeleiders: 1
Type - Identity Data(Type) - Assembly Code: 67,1; BERSnl_C_code_artikel: 0000-4278; BERSnl_C_code_ETIM: "Overige elektronische elementen schakelmateriaal"; BERSnl_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC000636&classVersion=7; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: duco_weerstation; BERSnl_C_IFC_versie: 2x3; BERSnl_C_model: weerstation; BERSnl_C_revit_versie: 2016; BERSnl_C_type: weerstation; BERSnl_C_type_comments: weerstation; Description: duco_weerstation; Manufacturer: Duco; Model: weerstation; Type Comments: weerstation; Type Name: weerstation_duco_bxhxd 94x126x96 mm; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 255 255 255 T00 wit_gen; BERSnl_C_materiaal_01: BERSnl_x_rgb 255 255 255 T00 wit_gen; BERSnl_C_materiaal_02: BERSnl_x_rgb 255 142 46 T00 goud_gen
Type - Model Properties(Type) - BERSnl_S_gewicht_bruto: 0.16; WT_I Kleur: wit/doorschijnend
Type - Other(Type) - Category: Communication Devices; BERSnl_E_c02_omschrijving: c02_bediening; Family Name: BERSnl_67_EF_FB_weerstation_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.065928 m2; Volume: 0.00227405 m3
Electrical - Circuiting - Electrical Data: c01_connector 24 V/1-24 VA
Graphics - WT_V Annotatie_positie x: 0; WT_V Annotatie_positie y: 0; WT_V Annotatie_verschuiving x richting: 0 mm; WT_V Annotatie_verschuiving y richting: 0 mm
Identity Data - Mark: 1
Other - BERSnl_E_c01_omschrijving: c01_connector; Category: Communication Devices; Family: BERSnl_67_EF_FB_weerstation_duco: weerstation_duco_bxhxd 94x126x96 mm; Family and Type: BERSnl_67_EF_FB_weerstation_duco: weerstation_duco_bxhxd 94x126x96 mm; Schedule Level: Level: Level 1; Type: BERSnl_67_EF_FB_weerstation_duco: weerstation_duco_bxhxd 94x126x96 mm; Type Id: BERSnl_67_EF_FB_weerstation_duco: weerstation_duco_bxhxd 94x126x96 mm
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
