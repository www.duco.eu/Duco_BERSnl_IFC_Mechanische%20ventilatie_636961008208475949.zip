Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:03:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:03:05 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{89967822-8DBF-4BE1-A0DE-EE4B2B277882}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:03:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:03:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:03:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: afvoerventiel - vierkant xl_duco_ducovent design, BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco:afvoerventiel - vierkant xl_duco_ducovent design:201501
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: BERSnl_n6_PVC_wit
Type - Constraints(Type) - Default Elevation: 2000 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 215 mm; BERSnl_C_diameter: 0 mm; BERSnl_C_diepte: 22 mm; BERSnl_C_hoogte: 73.5 mm; BERSnl_M_c01_diameter: 125 mm; WT_V Aansluitdiepte: 52 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; BERSnl_C_code_artikel: 4226; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 22/04/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V2; BERSnl_C_description: duco_ducovent design_afvoerventiel - vierkant xl; BERSnl_C_model: ducovent design; BERSnl_C_revit_versie: 2016; BERSnl_C_type: vierkant xl; BERSnl_C_type_comments: afvoerventiel; Cost: 0; Description: duco_ducovent design_afvoerventiel - vierkant xl; Manufacturer: Duco; Model: ducovent design; Type Comments: afvoerventiel; Type Name: afvoerventiel - vierkant xl_duco_ducovent design; URL: http://www.duco.eu/producten/luchtafvoer/afvoerventielen/nl-be-ducoventdesign; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_n6_PVC_wit
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveau: <15 dB(A) bij 50 m3/h; WT_I Inbouwhoogte: min. 18 cm boven de vloer; WT_I Kleur: Ral 9010_wit; WT_I Montage op minimium: minimium 60 cm van de muur en plafond
Type - Other(Type) - Category: Air Terminals; BERSnl_M_c01_drukverlies_statisch: 0 Pa; BERSnl_M_c01_omschrijving: c01_Retour; BERSnl_M_c01_straal: 62.5 mm; Family Name: BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: afvoerventiel - vierkant xl_duco_ducovent design
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.07783 m2; Size: 125 mmø; Volume: 0.00339754 m3
Identity Data - Mark: 2
Mechanical - System Classification: Return Air
Mechanical - Flow - BERSnl_M_debiet: 0 m3/s; Flow: 0 m3/s; WT_I Maximaal debiet: OK
Other - BERSnl_M_c01_debiet: 0 m3/s; Category: Air Terminals; Family: BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco: afvoerventiel - vierkant xl_duco_ducovent design; Family and Type: BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco: afvoerventiel - vierkant xl_duco_ducovent design; Schedule Level: Level: Level 1; Type: BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco: afvoerventiel - vierkant xl_duco_ducovent design; Type Id: BERSnl_57_AIR_FB_afvoerventiel - ducovent design_duco: afvoerventiel - vierkant xl_duco_ducovent design
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
