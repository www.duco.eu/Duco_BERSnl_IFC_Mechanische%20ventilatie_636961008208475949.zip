Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:02:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:02:24 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{067BB941-3EA4-429A-965A-52888E34B7F2}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:02:22 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:02:22 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:02:22 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: driewegklep met actuator_duco, BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco:driewegklep met actuator_duco:208264
In: Level 1
Type - Classification: 50 (Uniformat); Material: BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Dimensions(Type) - BERSnl_C_breedte: 160 mm; BERSnl_C_diepte: 36 mm; BERSnl_C_hoogte: 166 mm
Type - Identity Data(Type) - Assembly Code: 50; BERSnl_C_code_artikel: 0000-4424_DucoBox Eco All Electric Kit AE1_Driewegklep met actuator; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 20/12/2018; BERSnl_C_content_datum_uitgifte: 20/12/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: 1.0.0; BERSnl_C_description: driewegklep met actuator_duco; BERSnl_C_model: -; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; BERSnl_C_type_comments: -; Description: driewegklep met actuator_duco; Model: -; Type Comments: -; Type Name: driewegklep met actuator_duco; WT_I BaseKeynote: 50
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Other(Type) - Category: Pipe Accessories; BERSnl_P_c01_diameter: 25 mm; BERSnl_P_c02_diameter: 25 mm; BERSnl_P_c03_diameter: 25 mm; Family Name: BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco; WT_V P_c01_vlak: 5; WT_V P_c01_X: 0 mm; WT_V P_c01_Y: 0 mm; WT_V P_c01_Z: -20 mm; WT_V P_c02_vlak: 3; WT_V P_c02_X: 0 mm; WT_V P_c02_Y: 0 mm; WT_V P_c02_Z: -20 mm; WT_V P_c03_vlak: 6; WT_V P_c03_X: 0 mm; WT_V P_c03_Y: 0 mm; WT_V P_c03_Z: -20 mm
Pset_DistributionFlowElementCommon - Reference: driewegklep met actuator_duco
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.154921 m2; Maximum Size: 25 mm; Minimum Size: 25 mm; Size: 25 mmø-25 mmø-25 mmø; Volume: 0.0038259 m3
Identity Data - Mark: 1
Insulation - Insulation Thickness: 0 mm; Overall Size: 25 mmø-25 mmø-25 mmø
Mechanical - System Classification: Undefined
Other - Category: Pipe Accessories; Family: BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco: driewegklep met actuator_duco; Family and Type: BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco: driewegklep met actuator_duco; Type: BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco: driewegklep met actuator_duco; Type Id: BERSnl_50_PIA_UH_ducobox eco - electric kit - driewegklep met actuator_duco: driewegklep met actuator_duco
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
