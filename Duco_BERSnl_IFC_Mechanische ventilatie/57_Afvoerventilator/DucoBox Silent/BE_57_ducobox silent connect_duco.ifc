Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:03:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:03:58 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{C84AE52E-2224-484A-96EB-6B97A6FB5DFC}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:03:58 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:03:58 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:03:58 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcEnergyConversionDevice: ducobox silent connect_duco, BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco:ducobox silent connect_duco:205616
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: BERSnl_x_rgb 000 149 150 T00 groen_gen, BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Onderhoudszone_diepte: 500 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 480 mm; BERSnl_C_diepte: 195 mm; BERSnl_C_hoogte: 480 mm
Type - Electrical(Type) - BERSnl_E_c01_aantal_polen: 1; BERSnl_E_c01_arbeidsfactor: 1; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 230 W; BERSnl_E_c01_spanning: 230 V; BERSnl_E_c01_stroom: 1 A; BERSnl_E_c01_subklasse_motor: no
Type - Identity Data(Type) - Assembly Code: 57.21; BERSnl_C_code_artikel: 0000-4250; BERSnl_C_code_ETIM: Woonhuisventilator; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V5; BERSnl_C_description: ducobox silent connect_duco; BERSnl_C_model: DucoBox Silent; BERSnl_C_revit_versie: 2016; BERSnl_C_type_comments: afvoerventilator; Description: ducobox silent connect_duco; Manufacturer: Duco; Model: DucoBox Silent; OmniClass Number: 3A(57.31.11); Type Comments: afvoerventilator; Type Name: ducobox silent connect_duco; URL: http://www.duco.eu/architects/nl-nl-producten/nl-nl-luchtafvoer/nl-nl-mechanische-afvoer/nl-nl-ducoboxsilent; WT_I BaseKeynote: 57.21
Type - Mechanical(Type) - WT_V Capaciteit: 3.92385 m3/s; WT_V Opvoerhoogte: 150 Pa
Type - Model Properties(Type) - WT_I Afvoer_regeling: Centraal; WT_I Geluidsvermogen_aanzuig: 57.5; WT_I Geluidsvermogen_afstraling kast: 46.5; WT_I Gepatenteerd regelkleppensysteem: no
Type - Other(Type) - Category: Mechanical Equipment; BERSnl_E_c01_omschrijving: c01_Elektrische aansluiting; BERSnl_E_c02_omschrijving: c02_Communication aansluiting; BERSnl_M_c01_omschrijving: c01_Afblaas; BERSnl_M_c02_omschrijving: c02_Extractie 1; BERSnl_M_c03_omschrijving: c03_Extractie 2; BERSnl_M_c04_omschrijving: c04_Extractie 3; BERSnl_M_c05_omschrijving: c05_Extractie 4; BERSnl_M_c06_omschrijving: c06_Extractie 5; BERSnl_M_c06_straal: 62.5 mm; BERSnl_M_c07_omschrijving: c07_Extractie 6; BERSnl_M_c07_straal: 62.5 mm; BERSnl_M_c08_omschrijving: c08_Extractie 7; BERSnl_M_c08_straal: 62.5 mm; Family Name: BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco; NLRS_M_c01_radius: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: ducobox silent connect_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Aansturing_Draadloos: no; WT_V Aansturing_Opsteek IQ: yes; WT_V Aansturing_Opsteek PWM print + externe IQ: no; WT_V CO2 boxsensor: no; WT_V Communication Print: no; WT_V Communication Print_zichtbaar: no; WT_V EasySwitch: no; WT_V Eindkap zichtbaar_1: yes; WT_V Eindkap zichtbaar_2: yes; WT_V Eindkap zichtbaar_3: yes; WT_V Eindkap zichtbaar_4: yes; WT_V Eindkap zichtbaar_5: yes; WT_V Eindkap zichtbaar_6: yes; WT_V Eindkap zichtbaar_7: yes; WT_V Vocht boxsensor: no
Dimensions - Area: 1.2228 m2; Volume: 0.044928 m3
Graphics - WT_V Onderhoudszone zichtbaar: no
Identity Data - Mark: 3
Mechanical - System Classification: Return Air,Exhaust Air,Return Air,Power,Communication,Return Air
Mechanical - Flow - BERSnl_M_debiet: 0 m3/s
Other - BERSnl_M_c01_debiet: 0 m3/s; BERSnl_M_c02_debiet: 0 m3/s; BERSnl_M_c03_debiet: 0 m3/s; BERSnl_M_c03_straal: 62.5 mm; BERSnl_M_c04_debiet: 0 m3/s; BERSnl_M_c04_straal: 62.5 mm; BERSnl_M_c05_debiet: 0 m3/s; BERSnl_M_c05_straal: 62.5 mm; BERSnl_M_c06_debiet: 0 m3/s; BERSnl_M_c07_debiet: 0 m3/s; BERSnl_M_c08_debiet: 0 m3/s; Category: Mechanical Equipment; Family: BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco: ducobox silent connect_duco; Family and Type: BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco: ducobox silent connect_duco; NLRS_M_c02_radius: 62.5 mm; Schedule Level: Level: Level 1; Type: BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco: ducobox silent connect_duco; Type Id: BERSnl_57_ME_FB_afvoerventilator ducobox silent_duco: ducobox silent connect_duco
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
