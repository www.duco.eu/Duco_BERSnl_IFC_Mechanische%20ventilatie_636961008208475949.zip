Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:02:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:02:31 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{89E43E99-6A89-4C10-B55C-8233D4597E5D}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:02:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:02:29 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:02:29 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: boiler control_duco_bxhxd 193x146x60, BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco:boiler control_duco_bxhxd 193x146x60:207863
In: Level 1
Type - Classification: 53.10.80 (Uniformat); Material: BERSnl_x_rgb 20 20 20 T00 zwart_gen, BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 193 mm; BERSnl_C_diepte: 60 mm; BERSnl_C_hoogte: 146 mm
Type - Electrical Engineering(Type) - BERSnl_E_c01_aantal_polen: 1; BERSnl_E_c01_arbeidsfactor: 0; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 0 W; BERSnl_E_c01_spanning: 0 V; BERSnl_E_c01_stroom: 0 A; BERSnl_E_c01_subklasse_motor: yes
Type - Identity Data(Type) - Assembly Code: 53.10.80; BERSnl_C_code_artikel: 0000-4424_DucoBox Eco All Electric Kit AE1_Boiler Control; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 20/12/2018; BERSnl_C_content_datum_uitgifte: 20/12/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: 1.0.0; BERSnl_C_description: boiler control_duco; BERSnl_C_model: -; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; BERSnl_C_type_comments: -; Description: boiler control_duco; Model: -; Type Comments: -; Type Name: boiler control_duco_bxhxd 193x146x60; WT_I BaseKeynote: 53.10.80
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Model Properties(Type) - WT_I Aansluitingen: 1 x 230 VAC voeding 1 x Duco Wired 2 x schakelcontact (spanningsloze ingang) 4 x temperatuursensor 1 x Pompsturing 2 x relais; WT_I Communicatie: Wired; WT_I Drukknoppen: 1; WT_I LEDs: 1; WT_I Vermogen: 2 W; WT_I Voeding: 230 VAC
Type - Other(Type) - Category: Electrical Equipment; BERSnl_E_c01_omschrijving: c01_el; BERSnl_E_c02_omschrijving: c02_control; BERSnl_E_c03_omschrijving: c03_control; BERSnl_E_c04_omschrijving: c04_control; BERSnl_E_c05_omschrijving: c05_control; Family Name: BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco
Pset_BuildingElementProxyCommon - Reference: boiler control_duco_bxhxd 193x146x60
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0941935 m2; Volume: 0.00320445 m3
Electrical - Circuiting - Electrical Data: c01_el 0 V/1-0 VA
Identity Data - Mark: 1
Other - Category: Electrical Equipment; Family: BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco: boiler control_duco_bxhxd 193x146x60; Family and Type: BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco: boiler control_duco_bxhxd 193x146x60; Schedule Level: Level: Level 1; Type: BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco: boiler control_duco_bxhxd 193x146x60; Type Id: BERSnl_53_EE_FB_ducobox eco - electric kit - boiler control_duco: boiler control_duco_bxhxd 193x146x60
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
