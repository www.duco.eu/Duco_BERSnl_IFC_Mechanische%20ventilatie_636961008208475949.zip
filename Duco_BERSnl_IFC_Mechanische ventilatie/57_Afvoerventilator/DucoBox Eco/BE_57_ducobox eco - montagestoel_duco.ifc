Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:04:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:04:13 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{54FF8D8F-8CDE-45DF-971C-5823F57453BE}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:04:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:04:13 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:04:13 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionControlElement: montagestoel hangend_duco, BERSnl_59_ME_FB_montagestoel - SH_duco:montagestoel hangend_duco:212166
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: BERSnl_x_rgb 248 248 248 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Construction(Type) - WT_V Hangend: yes
Type - Dimensions(Type) - BERSnl_C_breedte: 740 mm; BERSnl_C_diameter: 0 mm; BERSnl_C_diepte: 568 mm; BERSnl_C_hoogte: 1032 mm
Type - Identity Data(Type) - Assembly Code: 67.10.10; BERSnl_C_code_artikel: 0000-4422; BERSnl_C_code_ETIM: Woonhuisventilator; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V2; BERSnl_C_description: montagestoel hangend_duco; BERSnl_C_IFC_versie: 2x3; BERSnl_C_model: montagestoel; BERSnl_C_revit_versie: 2016; BERSnl_C_type: hangend; BERSnl_C_type_comments: duco_montagestoel hangend; Description: montagestoel hangend_duco; Manufacturer: Duco; Model: montagestoel; OmniClass Number: 23.75.70.17.37; OmniClass Title: Unit Ventilators; Type Comments: duco_montagestoel hangend; Type Name: montagestoel hangend_duco; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-boxsensor; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 248 248 248 T00 wit_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: BERSnl_59_ME_FB_montagestoel - SH_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Moves With Nearby Elements: no; Offset: 1 mm
Dimensions - Area: 0.546266 m2; Volume: 0.0125291 m3
Identity Data - Mark: 5
Other - Category: Mechanical Equipment; Family: BERSnl_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Family and Type: BERSnl_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Type: BERSnl_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Type Id: BERSnl_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco

# IfcEnergyConversionDevice: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612, BERSnl_57_ME_FB_wtw unit ducobox eco_duco:0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612:212164
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: BERSnl_x_rgb 20 20 20 T00 zwart_gen, BERSnl_x_rgb 255 255 255 T00 wit_gen, BERSnl_x_rgb 000 149 150 T00 groen_gen
Type - Constraints(Type) - Default Elevation: 1000 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 657 mm; BERSnl_C_diepte: 612 mm; BERSnl_C_hoogte: 715 mm
Type - Electrical(Type) - BERSnl_E_c01_aantal_polen: 1; BERSnl_E_c01_arbeidsfactor: 1; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 230 W; BERSnl_E_c01_spanning: 230 V; BERSnl_E_c01_stroom: 1 A; BERSnl_E_c01_subklasse_motor: no
Type - Identity Data(Type) - Assembly Code: 57.21; BERSnl_C_code_artikel: 0000-4410; BERSnl_C_code_ETIM: WTW apparaat eengezinswoning; BERSnl_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011285&classVersion=3; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: ducobox eco - hangend_duco; BERSnl_C_model: DucoBox Eco; BERSnl_C_revit_versie: 2016; BERSnl_C_type: Hangend; BERSnl_C_type_comments: -; Description: ducobox eco - hangend_duco; Manufacturer: Duco; Model: DucoBox Eco; OmniClass Number: 3A(57.31.11); Type Comments: -; Type Name: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612; WT_I BaseKeynote: 57.21
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 000 149 150 T00 groen_gen; BERSnl_C_materiaal_01: BERSnl_x_rgb 000 149 150 T00 groen_gen; BERSnl_C_materiaal_02: BERSnl_x_rgb 255 255 255 T00 wit_gen; BERSnl_C_materiaal_03: BERSnl_x_rgb 20 20 20 T00 zwart_gen; WT_V Maintenance zones_materiaal: BERSnl_x_rgb 255 0 0 T80 rood_gen
Type - Mechanical(Type) - WT_V Capaciteit: 4.51243 m3/s; WT_V Opvoerhoogte: 150 Pa
Type - Model Properties(Type) - WT_I Afvoercapaciteit bij 150 Pa: 400 m³/h; WT_I Binnendiameter: 160 mm; WT_I Buitendiameter: 190 mm; WT_I Energieklasse: A+; WT_I Gewicht: 70 kg; WT_I Heater: n.v.t.; WT_I Piekvermogen: 1200 W; WT_I Zoneregeling: 2 zones
Type - Other(Type) - Category: Mechanical Equipment; BERSnl_E_c01_omschrijving: c01_Elektrische aansluiting; BERSnl_E_c02_omschrijving: c02_Communication aansluiting; BERSnl_M_c01_diameter: 180 mm; BERSnl_M_c01_omschrijving: c01_afvoer naar buiten_EHA; BERSnl_M_c02_diameter: 180 mm; BERSnl_M_c02_omschrijving: c02_toevoer van buiten_ODA; BERSnl_M_c03_diameter: 160 mm; BERSnl_M_c03_omschrijving: c03_afvoer van binnen_ETA 1; BERSnl_M_c04_diameter: 160 mm; BERSnl_M_c04_omschrijving: c04_afvoer van binnen_ETA 2; BERSnl_P_c01_diameter: 22 mm; BERSnl_P_c01_omschrijving: c01_ water SUP; BERSnl_P_c02_diameter: 22 mm; BERSnl_P_c02_omschrijving: c02_ water RET; BERSnl_P_c03_belastingswaarde: 0; BERSnl_P_c03_diameter: 32 mm; BERSnl_P_c03_omschrijving: c03_ condensafvoer; Family Name: BERSnl_57_ME_FB_wtw unit ducobox eco_duco; WT_V M_c01_rotatie uit vlak: 0 deg; WT_V M_c01_vlak: 4; WT_V M_c01_X: -200 mm; WT_V M_c01_Y: -98 mm; WT_V M_c01_Z: -50 mm; WT_V M_c02_rotatie uit vlak: 0 deg; WT_V M_c02_vlak: 4; WT_V M_c02_X: 200 mm; WT_V M_c02_Y: -98 mm; WT_V M_c02_Z: -50 mm; WT_V M_c03_rotatie uit vlak: 0 deg; WT_V M_c03_vlak: 4; WT_V M_c03_X: 200 mm; WT_V M_c03_Y: 162 mm; WT_V M_c03_Z: -50 mm; WT_V M_c04_rotatie uit vlak: 0 deg; WT_V M_c04_vlak: 4; WT_V M_c04_X: -200 mm; WT_V M_c04_Y: 162 mm; WT_V M_c04_Z: -50 mm; WT_V P_c01_rotatie uit vlak: 0 deg; WT_V P_c01_vlak: 3; WT_V P_c01_X: -266 mm; WT_V P_c01_Y: -232 mm; WT_V P_c01_Z: 45 mm; WT_V P_c02_rotatie uit vlak: 0 deg; WT_V P_c02_vlak: 3; WT_V P_c02_X: -107.5 mm; WT_V P_c02_Y: -232 mm; WT_V P_c02_Z: 45 mm; WT_V P_c03_rotatie uit vlak: 0 deg; WT_V P_c03_vlak: 3; WT_V P_c03_X: 200 mm; WT_V P_c03_Y: 162 mm; WT_V P_c03_Z: 45 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Coax kabel: no; WT_V Extractie 1_regelklep: BERSnl_59_ME_FB_ducobox eco - regelklep - SH_duco: 160mm - sensorless regelklep_duco; WT_V Extractie 2_regelklep: geen_witas; WT_V Extractie 3_regelklep: geen_witas; WT_V Extractie 4_regelklep: geen_witas; WT_V Platte sifon: no
Dimensions - Area: 23.024 m2; Volume: 5.63735 m3
Graphics - WT_V Onderhoudszone zichtbaar: no
Identity Data - Mark: 3
Mechanical - System Classification: Exhaust Air,Supply Air,Return Air,Hydronic Supply,Hydronic Return,Sanitary,Power,Communication
Mechanical - Flow - BERSnl_M_debiet: 0 m3/s
Other - BERSnl_M_c01_debiet: 0 m3/s; BERSnl_M_c02_debiet: 0 m3/s; BERSnl_M_c03_debiet: 0 m3/s; BERSnl_M_c04_debiet: 0 m3/s; BERSnl_P_c01_volumestroom: 0 m3/s; BERSnl_P_c02_volumestroom: 0 m3/s; Category: Mechanical Equipment; Family: BERSnl_57_ME_FB_wtw unit ducobox eco_duco: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612; Family and Type: BERSnl_57_ME_FB_wtw unit ducobox eco_duco: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612; Schedule Level: Level: Level 1; Type: BERSnl_57_ME_FB_wtw unit ducobox eco_duco: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612; Type Id: BERSnl_57_ME_FB_wtw unit ducobox eco_duco: 0000-4410 - ducobox eco - montagestoel_duco_bxhxd 657x715x612
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
