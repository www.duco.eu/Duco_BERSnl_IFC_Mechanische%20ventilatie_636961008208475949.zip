Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:02:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:02:52 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{2F933523-7E81-41A7-8F2E-5EA0671607A2}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:02:51 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:02:51 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:02:51 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: verswaterstation_duco_bxhxd 420x355x221, BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco:verswaterstation_duco_bxhxd 420x355x221:207899
In: Level 1
Type - Classification: 53.10.10 (Uniformat); Material: BERSnl_x_rgb 20 20 20 T00 zwart_gen, BERSnl_x_rgb 255 255 255 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 420 mm; BERSnl_C_diepte: 221 mm; BERSnl_C_hoogte: 355 mm
Type - Electrical Engineering(Type) - BERSnl_E_c01_aantal_polen: 1; BERSnl_E_c01_arbeidsfactor: 0; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_schijnbaar_vermogen: 0 W; BERSnl_E_c01_spanning: 0 V; BERSnl_E_c01_stroom: 0 A; BERSnl_E_c01_subklasse_motor: yes
Type - Identity Data(Type) - Assembly Code: 53.10.10; BERSnl_C_code_artikel: 0000-4424_DucoBox Eco All Electric Kit AE1_Verswaterstation; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 20/12/2018; BERSnl_C_content_datum_uitgifte: 20/12/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: 1.0.0; BERSnl_C_description: verswaterstation_duco; BERSnl_C_model: -; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; BERSnl_C_type_comments: -; Description: verswaterstation_duco; Model: -; Type Comments: -; Type Name: verswaterstation_duco_bxhxd 420x355x221; WT_I BaseKeynote: 53.10.10
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 20 20 20 T00 zwart_gen
Type - Other(Type) - Category: Mechanical Equipment; BERSnl_E_c01_omschrijving: c01_el; BERSnl_E_c02_omschrijving: c02_control; BERSnl_P_c01_diameter: 25 mm; BERSnl_P_c01_omschrijving: c01_CW; BERSnl_P_c02_diameter: 25 mm; BERSnl_P_c02_omschrijving: c02_HW; BERSnl_P_c03_diameter: 25 mm; BERSnl_P_c03_omschrijving: c03_CW; BERSnl_P_c04_diameter: 25 mm; BERSnl_P_c04_omschrijving: c04_HW; Family Name: BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco; WT_V P_c01_rotatie uit vlak: 0 deg; WT_V P_c01_vlak: 1; WT_V P_c01_X: 150 mm; WT_V P_c01_Y: 39.5 mm; WT_V P_c01_Z: 0 mm; WT_V P_c02_rotatie uit vlak: 0 deg; WT_V P_c02_vlak: 1; WT_V P_c02_X: 70 mm; WT_V P_c02_Y: 39.5 mm; WT_V P_c02_Z: 0 mm; WT_V P_c03_rotatie uit vlak: 0 deg; WT_V P_c03_vlak: 2; WT_V P_c03_X: -150 mm; WT_V P_c03_Y: 39.5 mm; WT_V P_c03_Z: 0 mm; WT_V P_c04_rotatie uit vlak: 0 deg; WT_V P_c04_vlak: 2; WT_V P_c04_X: -70 mm; WT_V P_c04_Y: 39.5 mm; WT_V P_c04_Z: 0 mm
Pset_BuildingElementProxyCommon - Reference: verswaterstation_duco_bxhxd 420x355x221
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 1.91439 m2; Volume: 0.196563 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water,Domestic Cold Water,Domestic Hot Water,Power,Controls
Other - BERSnl_P_c01_volumestroom: 0 m3/s; BERSnl_P_c02_volumestroom: 0 m3/s; BERSnl_P_c03_volumestroom: 0 m3/s; BERSnl_P_c04_volumestroom: 0 m3/s; Category: Mechanical Equipment; Family: BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco: verswaterstation_duco_bxhxd 420x355x221; Family and Type: BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco: verswaterstation_duco_bxhxd 420x355x221; Schedule Level: Level: Level 1; Type: BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco: verswaterstation_duco_bxhxd 420x355x221; Type Id: BERSnl_53_ME_FB_ducobox eco - electric kit - verswaterstation_duco: verswaterstation_duco_bxhxd 420x355x221
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
