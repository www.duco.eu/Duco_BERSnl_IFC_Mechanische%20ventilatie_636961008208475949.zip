Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:03:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:03:15 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{569C23C9-D771-4492-885F-F731D3EB505E}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:03:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:03:13 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:03:13 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: doorvent_duco_doorvent, BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco:doorvent_duco_doorvent:205045
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: BERSnl_h4_aluminium, BERSnl_n_plastic_zwart
Type - Constraints(Type) - Default Elevation: 200 mm
Type - Dimensions(Type) - BERSnl_C_hoogte: 58 mm; BERSnl_C_lengte: 436 mm; WT_V Roosterhoogte: 45 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; BERSnl_C_code_artikel: DoorVent; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_luchtdoorvoerrooster_doorvent; BERSnl_C_model: DucoVent; BERSnl_C_revit_versie: 2016; Manufacturer: Duco; Model: DucoVent; OmniClass Number: 3A(57.16.11); Type Name: doorvent_duco_doorvent; URL: http://www.duco.eu/producten/specificaties.cfm?prod=126&pid=3-126&cat=126; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.52972 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.245241 m3/s
Type - Model Properties(Type) - WT_I Deur_MAX diepte: 47 mm; WT_I Deur_MIN diepte: 37 mm; WT_I Geluidsniveauverschil Dne, W_in open stand: 32 dB; WT_I Kleur: F1 - RAL; WT_I Luchtdoorlaat: 0.007 m2
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: doorvent_duco_doorvent
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Deur_diepte: 37 mm
Dimensions - Area: 0.159529 m2; BERSnl_C_diepte: 41 mm; Volume: 0.000968693 m3
Identity Data - Mark: 1
Mechanical - Flow - BE_M Drukverschil 10Pa: no; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 0.101284 m3/s
Other - Category: Air Terminals; Family: BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Family and Type: BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Schedule Level: Level: Level 1; Type: BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Type Id: BERSnl_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
