Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:03:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:03:41 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{A9CB883A-FFF8-4390-A36E-E385EE1BE94B}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:03:39 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:03:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:03:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowFitting: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk, BERSnl_57_DUF_UN_verdeelstuk_duco:2 x 125mm naar 1 x 160 mm_duco_verdeelstuk:200195
In: Level 1
Type - PredefinedType: TRANSITION; Classification: 57,1 (Uniformat); Material: BERSnl_x_rgb 251 251 251 T00 wit_gen, BERSnl_x_rgb 57 58 60 T00 zwart_gen
Type - Construction(Type) - WT_V Afstand_01: -18 mm; WT_V Afstand_02: -46 mm; WT_V Afstand_03: -46 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 328 mm; BERSnl_C_diepte: 173 mm; BERSnl_C_hoogte: 310 mm
Type - Identity Data(Type) - Assembly Code: 57,1; BERSnl_C_code_artikel: 0000-4454; BERSnl_C_code_ETIM: "Fitting met 3 aansluitingen"; BERSnl_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC003025&classVersion=2; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: duco_verdeelstuk - 2 x 125 mm naar 1 x 160 mm; BERSnl_C_IFC_versie: 2016; BERSnl_C_model: verdeelstuk; BERSnl_C_revit_versie: 2016; BERSnl_C_type: 2 x 125 mm naar 1 x 160 mm; BERSnl_C_type_comments: verdeelstuk; Description: duco_verdeelstuk - 2 x 125 mm naar 1 x 160 mm; Manufacturer: Duco; Model: verdeelstuk; Type Comments: verdeelstuk; Type Name: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk; URL: http://www.duco.eu/nl-nl-producten/nl-nl-luchtafvoer/nl-nl-toebehoren/nl-nl-broekstuk; WT_I BaseKeynote: 57.10
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_x_rgb 57 58 60 T00 zwart_gen
Type - Other(Type) - Category: Duct Fittings; BERSnl_M_c01_diameter: 160 mm; BERSnl_M_c02_diameter: 125 mm; BERSnl_M_c03_diameter: 125 mm; Family Name: BERSnl_57_DUF_UN_verdeelstuk_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.235327 m2; Size: 160 mmø-125 mmø-125 mmø; Volume: 0.0127947 m3
Identity Data - Mark: 1
Insulation - Insulation Thickness: 0 mm; Overall Size: 160 mmø-125 mmø-125 mmø
Lining - Free Size: 160 mmø-125 mmø-125 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Other - Category: Duct Fittings; Family: BERSnl_57_DUF_UN_verdeelstuk_duco: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk; Family and Type: BERSnl_57_DUF_UN_verdeelstuk_duco: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk; Type: BERSnl_57_DUF_UN_verdeelstuk_duco: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk; Type Id: BERSnl_57_DUF_UN_verdeelstuk_duco: 2 x 125mm naar 1 x 160 mm_duco_verdeelstuk
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
